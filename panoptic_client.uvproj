# Keil uVision project panoptic_client.uvproj, settings and files
target LM3S8962 (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M3")
  output: Http_demo
  c flags: Optim=4
  c include: ..\Library
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Files
    ./: panoptic_client.c common.c main.c int80_api.c
  group Configuration Files
    ./: Net_Config.c Net_Debug.c RTX_Config.c Startup.s Startup_RTX.s
  group Library
    C:/Keil/ARM/RV31/LIB/Luminary/: DriverLib.lib
    C:/Keil/ARM/Boards/Luminary/ek-lm3s8962/RL/TCPnet/Library/: LM3S_EMAC.c
    C:/Keil/ARM/Boards/Luminary/ek-lm3s8962/: rit128x96x4.c
    C:/StellarisWare/utils/: ustdlib.c uartstdio.c
    ./: jansson.lib
    ../luminary/RV31/LIB/: TCPD_CM3.lib TCP_CM3.lib
  group jansson-2.0
    ./jansson-2.0/src/: dump.c error.c hashtable.c load.c memory.c pack_unpack.c strbuffer.c utf.c value.c
target LM3S8962 Debug (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: as above
  output: panoptic_rtx_agent
  c flags: Optim=1 wLevel=2
  c define: RTX_KERNEL
  c include: ..\Library;C:\StellarisWare;C:\StellarisWare\boards\ek-lm3s8962;..\luminary\RL\TCPnet\SRC;.\jansson-2.0\src
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
target LM3S8962 RTX (ARM-ADS)
  device: LM3S8962 Luminary Micro
  cpu: as above
  output: Http_demo
  c flags: Optim=4
  c define: RTX_KERNEL
  c include: ..\Library;C:\StellarisWare\third_party\lwip-1.3.2\src;C:\StellarisWare\third_party\lwip-1.3.2\src\include;C:\StellarisWare\third_party\lwip-1.3.2\ports\stellaris\include;..\panoptic_rtx_agent;C:\StellarisWare\third_party\lwip-1.3.2\src\include\ipv4;C:\StellarisWare;Y:\dev\arm\StellarisWare\third_party\lwip-1.3.2\apps\httpserver_raw
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
